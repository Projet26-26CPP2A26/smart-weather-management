// ============================================================================
// PROJET SMART WEATHER MANAGEMENT - MODULE 1 : GESTION DES EMPLOYÉS
// SEMAINE 10 : IMPLÉMENTATION StationMeteo
// ÉTUDIANTE : SALMA RIDENE
// ============================================================================

#include "stationmeteo.h"
#include <QSqlQuery>
#include <QSqlError>
#include <QSqlQueryModel>
#include <QDateTime>
#include <QDebug>
#include <QStringList>

// ── Constructeur ─────────────────────────────────────────────────────────────
StationMeteo::StationMeteo(const QString &stationId)
    : m_stationId(stationId)
{}

// ── Crée les tables RELEVE_METEO et ALERTE_METEO si absentes ─────────────────
bool StationMeteo::initialiserTables()
{
    QSqlQuery q;
    bool ok = true;

    // ── Détection du driver (Oracle vs SQLite) ────────────────────────────
    bool isOracle = QSqlDatabase::database().driverName().contains("ODBC", Qt::CaseInsensitive)
                 || QSqlDatabase::database().driverName().contains("OCI",  Qt::CaseInsensitive);

    // ── Table RELEVE_METEO ─────────────────────────────────────────────────
    if (!tableExiste("RELEVE_METEO")) {
        QString sql;
        if (isOracle) {
            sql = R"(
                CREATE TABLE RELEVE_METEO (
                    id_releve    NUMBER GENERATED BY DEFAULT AS IDENTITY PRIMARY KEY,
                    date_releve  VARCHAR2(30)  NOT NULL,
                    temperature  NUMBER(6,2)   NOT NULL,
                    humidite     NUMBER(5,2)   NOT NULL,
                    pluie_adc    NUMBER(5)     NOT NULL,
                    gel_detecte  VARCHAR2(3)   DEFAULT 'Non',
                    station_id   VARCHAR2(50)  NOT NULL,
                    CONSTRAINT chk_gel CHECK (gel_detecte IN ('Oui','Non'))
                )
            )";
        } else {
            sql = R"(
                CREATE TABLE IF NOT EXISTS RELEVE_METEO (
                    id_releve    INTEGER PRIMARY KEY AUTOINCREMENT,
                    date_releve  TEXT    NOT NULL,
                    temperature  REAL    NOT NULL,
                    humidite     REAL    NOT NULL,
                    pluie_adc    INTEGER NOT NULL,
                    gel_detecte  TEXT    DEFAULT 'Non',
                    station_id   TEXT    NOT NULL
                )
            )";
        }
        if (!q.exec(sql)) {
            qWarning() << "StationMeteo: création RELEVE_METEO échouée:" << q.lastError().text();
            ok = false;
        } else {
            qDebug() << "StationMeteo: table RELEVE_METEO créée.";
        }
    }

    // ── Table ALERTE_METEO ─────────────────────────────────────────────────
    if (!tableExiste("ALERTE_METEO")) {
        QString sql;
        if (isOracle) {
            sql = R"(
                CREATE TABLE ALERTE_METEO (
                    id_alerte    NUMBER GENERATED BY DEFAULT AS IDENTITY PRIMARY KEY,
                    date_alerte  VARCHAR2(30) NOT NULL,
                    station_id   VARCHAR2(50) NOT NULL,
                    type_alerte  VARCHAR2(100) NOT NULL,
                    temperature  NUMBER(6,2),
                    humidite     NUMBER(5,2),
                    pluie_adc    NUMBER(5),
                    gel_detecte  VARCHAR2(3)   DEFAULT 'Non',
                    traitee      VARCHAR2(3)   DEFAULT 'Non',
                    CONSTRAINT chk_alerte_gel    CHECK (gel_detecte IN ('Oui','Non')),
                    CONSTRAINT chk_alerte_traitee CHECK (traitee    IN ('Oui','Non'))
                )
            )";
        } else {
            sql = R"(
                CREATE TABLE IF NOT EXISTS ALERTE_METEO (
                    id_alerte    INTEGER PRIMARY KEY AUTOINCREMENT,
                    date_alerte  TEXT    NOT NULL,
                    station_id   TEXT    NOT NULL,
                    type_alerte  TEXT    NOT NULL,
                    temperature  REAL,
                    humidite     REAL,
                    pluie_adc    INTEGER,
                    gel_detecte  TEXT    DEFAULT 'Non',
                    traitee      TEXT    DEFAULT 'Non'
                )
            )";
        }
        if (!q.exec(sql)) {
            qWarning() << "StationMeteo: création ALERTE_METEO échouée:" << q.lastError().text();
            ok = false;
        } else {
            qDebug() << "StationMeteo: table ALERTE_METEO créée.";
        }
    }

    return ok;
}

// ── Vérifie l'existence d'une table ──────────────────────────────────────────
bool StationMeteo::tableExiste(const QString &nom)
{
    return QSqlDatabase::database().tables(QSql::Tables)
               .contains(nom, Qt::CaseInsensitive);
}

// ── Enregistre un relevé dans RELEVE_METEO ────────────────────────────────────
bool StationMeteo::enregistrerReleve(double temp, double hum, int pluie, bool gel)
{
    QSqlQuery q;
    q.prepare(R"(
        INSERT INTO RELEVE_METEO
            (date_releve, temperature, humidite, pluie_adc, gel_detecte, station_id)
        VALUES
            (:dt, :t, :h, :p, :g, :s)
    )");
    q.bindValue(":dt", QDateTime::currentDateTime().toString("yyyy-MM-dd HH:mm:ss"));
    q.bindValue(":t",  temp);
    q.bindValue(":h",  hum);
    q.bindValue(":p",  pluie);
    q.bindValue(":g",  gel ? "Oui" : "Non");
    q.bindValue(":s",  m_stationId);

    if (!q.exec()) {
        qWarning() << "StationMeteo::enregistrerReleve échec:" << q.lastError().text();
        return false;
    }
    return true;
}

// ── Retourne un modèle des derniers relevés (pour QTableView) ─────────────────
QSqlQueryModel *StationMeteo::afficherReleves(int limite) const
{
    auto *model = new QSqlQueryModel();
    model->setQuery(QString(
        "SELECT id_releve        AS \"ID\","
        "       date_releve      AS \"Date / Heure\","
        "       temperature      AS \"Temp (°C)\","
        "       humidite         AS \"Hum (%)\","
        "       pluie_adc        AS \"Pluie (ADC)\","
        "       gel_detecte      AS \"Gel\","
        "       station_id       AS \"Station\""
        " FROM  RELEVE_METEO"
        " ORDER BY id_releve DESC"
        " FETCH FIRST %1 ROWS ONLY").arg(limite));

    if (model->lastError().isValid()) {
        // Fallback SQLite (LIMIT au lieu de FETCH FIRST)
        model->setQuery(QString(
            "SELECT id_releve   AS 'ID',"
            "       date_releve AS 'Date / Heure',"
            "       temperature AS 'Temp (°C)',"
            "       humidite    AS 'Hum (%)',"
            "       pluie_adc   AS 'Pluie (ADC)',"
            "       gel_detecte AS 'Gel',"
            "       station_id  AS 'Station'"
            " FROM  RELEVE_METEO"
            " ORDER BY id_releve DESC"
            " LIMIT %1").arg(limite));
    }
    return model;
}

// ── Évalue si un relevé dépasse les seuils d'alerte ──────────────────────────
bool StationMeteo::detecterAlerte(const ReleverMeteo &r) const
{
    if (r.temperature > seuilTempMax)  return true;   // chaleur excessive
    if (r.humidite    < seuilHumMin)   return true;   // sécheresse
    if (r.pluie       > seuilPluieMax) return true;   // pluie forte
    if (r.gelDetecte)                  return true;   // risque de gel
    return false;
}

// ── Insère une alerte dans ALERTE_METEO ──────────────────────────────────────
void StationMeteo::creerAlerteBD(const ReleverMeteo &r, const QString &message)
{
    QSqlQuery q;
    q.prepare(R"(
        INSERT INTO ALERTE_METEO
            (date_alerte, station_id, type_alerte,
             temperature, humidite, pluie_adc, gel_detecte, traitee)
        VALUES
            (:da, :s, :ta, :t, :h, :p, :g, 'Non')
    )");
    q.bindValue(":da", QDateTime::currentDateTime().toString("yyyy-MM-dd HH:mm:ss"));
    q.bindValue(":s",  m_stationId);
    q.bindValue(":ta", message);
    q.bindValue(":t",  r.temperature);
    q.bindValue(":h",  r.humidite);
    q.bindValue(":p",  r.pluie);
    q.bindValue(":g",  r.gelDetecte ? "Oui" : "Non");

    if (!q.exec())
        qWarning() << "StationMeteo::creerAlerteBD échec:" << q.lastError().text();
    else
        qDebug() << "StationMeteo: alerte enregistrée:" << message;
}

// ── Parsing d'une ligne série ─────────────────────────────────────────────────
// Format attendu : "T:28.50,H:65.30,R:120,GEL:0"
bool StationMeteo::parseLigneSerie(const QString &ligne,
                                   double &temp, double &hum,
                                   int    &pluie, bool &gel)
{
    // Réinitialisation
    temp = hum = 0.0;
    pluie = 0;
    gel = false;

    if (!ligne.startsWith("T:")) return false;

    // Découper sur ','
    QStringList parts = ligne.split(',', Qt::SkipEmptyParts);
    if (parts.size() < 4) return false;

    bool ok1, ok2, ok3, ok4;
    // T:28.50
    temp  = parts[0].mid(2).toDouble(&ok1);
    // H:65.30
    hum   = parts[1].mid(2).toDouble(&ok2);
    // R:120
    pluie = parts[2].mid(2).toInt(&ok3);
    // GEL:0 ou GEL:1
    int gelInt = parts[3].mid(4).toInt(&ok4);
    gel = (gelInt == 1);

    return ok1 && ok2 && ok3 && ok4;
}

